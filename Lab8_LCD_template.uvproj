# Keil uVision project Lab8_LCD_template.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Lab8_LCD_template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: startup_LPC11xx.s LCD_driver.c main.c LCD_driver.h keypad_scanner.c keypad_scanner.h ADC.c ADC.h timer.c timer.h UART.c UART.h SPI.c SPI.h
    C:/Keil_v5/ARM/Startup/NXP/LPC11xx/: system_LPC11xx.c
